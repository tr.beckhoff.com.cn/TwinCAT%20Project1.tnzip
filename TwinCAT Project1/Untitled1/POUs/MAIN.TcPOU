PROGRAM MAIN
VAR
	n1 AT%MB0 :WORD;
	n2 AT%MB2 :WORD;
END_VAR

n1:=n1+1;
n2:=n2+1;

END_PROGRAM
