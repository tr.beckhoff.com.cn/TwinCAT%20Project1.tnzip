{attribute 'qualified_only'}
VAR_GLOBAL
	
END_VAR
